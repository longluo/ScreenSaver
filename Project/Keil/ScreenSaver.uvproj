# Keil uVision project ScreenSaver.uvproj, settings and files
target ScreenSaver (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ScreenSaver +hex
  c flags: Optim=2 oTime=1
  c include: ..\..\Source\App\Head;..\..\Source\HAL\Oled\Head;..\..\Source\LM3S_Lib\inc;..\..\Source\Utils\Head;..\..\Source\Random
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../Source/App/Src/: main.c screen_saver.c
    ../../Source/Random/: random.c
  group HAL
    ../../Source/HAL/: Startup_rvmdk.s
    ../../Source/HAL/Oled/Src/: rit128x96x4.c
  group Utils
    ../../Source/Utils/Src/: uartstdio.c ustdlib.c
  group LM3S_Drv_Lib
    ../../Source/LM3S_Lib/DriverLib/: driverlib.lib
